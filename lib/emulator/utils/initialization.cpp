#include "utils/initialization.h"
#include "cpu/cpu.h"



void loadBootRom (State *state)
{
  Byte boot_room_data [] = {
    0x31, 0xFE, 0xFF, 0xAF, 0x21, 0xFF, 0x9F, 0x32, 0xCB, 0x7C, 0x20, 0xFB, 0x21, 0x26, 0xFF, 0x0E,
    0x11, 0x3E, 0x80, 0x32, 0xE2, 0x0C, 0x3E, 0xF3, 0xE2, 0x32, 0x3E, 0x77, 0x77, 0x3E, 0xFC, 0xE0,
    0x47, 0x11, 0x04, 0x01, 0x21, 0x10, 0x80, 0x1A, 0xCD, 0x95, 0x00, 0xCD, 0x96, 0x00, 0x13, 0x7B,
    0xFE, 0x34, 0x20, 0xF3, 0x11, 0xD8, 0x00, 0x06, 0x08, 0x1A, 0x13, 0x22, 0x23, 0x05, 0x20, 0xF9,
    0x3E, 0x19, 0xEA, 0x10, 0x99, 0x21, 0x2F, 0x99, 0x0E, 0x0C, 0x3D, 0x28, 0x08, 0x32, 0x0D, 0x20,
    0xF9, 0x2E, 0x0F, 0x18, 0xF3, 0x67, 0x3E, 0x64, 0x57, 0xE0, 0x42, 0x3E, 0x91, 0xE0, 0x40, 0x04,
    0x1E, 0x02, 0x0E, 0x0C, 0xF0, 0x44, 0xFE, 0x90, 0x20, 0xFA, 0x0D, 0x20, 0xF7, 0x1D, 0x20, 0xF2,
    0x0E, 0x13, 0x24, 0x7C, 0x1E, 0x83, 0xFE, 0x62, 0x28, 0x06, 0x1E, 0xC1, 0xFE, 0x64, 0x20, 0x06,
    0x7B, 0xE2, 0x0C, 0x3E, 0x87, 0xE2, 0xF0, 0x42, 0x90, 0xE0, 0x42, 0x15, 0x20, 0xD2, 0x05, 0x20,
    0x4F, 0x16, 0x20, 0x18, 0xCB, 0x4F, 0x06, 0x04, 0xC5, 0xCB, 0x11, 0x17, 0xC1, 0xCB, 0x11, 0x17,
    0x05, 0x20, 0xF5, 0x22, 0x23, 0x22, 0x23, 0xC9, 0xCE, 0xED, 0x66, 0x66, 0xCC, 0x0D, 0x00, 0x0B,
    0x03, 0x73, 0x00, 0x83, 0x00, 0x0C, 0x00, 0x0D, 0x00, 0x08, 0x11, 0x1F, 0x88, 0x89, 0x00, 0x0E,
    0xDC, 0xCC, 0x6E, 0xE6, 0xDD, 0xDD, 0xD9, 0x99, 0xBB, 0xBB, 0x67, 0x63, 0x6E, 0x0E, 0xEC, 0xCC,
    0xDD, 0xDC, 0x99, 0x9F, 0xBB, 0xB9, 0x33, 0x3E, 0x3C, 0x42, 0xB9, 0xA5, 0xB9, 0xA5, 0x42, 0x3C,
    0x21, 0x04, 0x01, 0x11, 0xA8, 0x00, 0x1A, 0x13, 0xBE, 0x20, 0xFE, 0x23, 0x7D, 0xFE, 0x34, 0x20,
    0xF5, 0x06, 0x19, 0x78, 0x86, 0x23, 0x05, 0x20, 0xFB, 0x86, 0x20, 0xFE, 0x3E, 0x01, 0xE0, 0x50
  };

  for (Short i = 0; i < sizeof(boot_room_data); i++) {
    state->memory[i] = boot_room_data[i];
  }
}


void loadGame (State *state, GameRom *game_rom)
{
  if (game_rom == nullptr) {
    return;
  }
  for (Short i = 0x0000; i < 0x0100; i++) {
    state->game_boot_rom[i] = (*game_rom)[i];
  }
  for (Short i = 0x0100; i < 0x8000; i++) {
    state->memory[i] = (*game_rom)[i];
  }
}


void setPostBootState (State *state) {
  state->A = 0x01;
  state->B = 0x00;
  state->C = 0x13;
  state->D = 0x00;
  state->E = 0xD8;
  state->F = 0x80;
  state->H = 0x01;
  state->L = 0x4D;
  state->SP = 0xFFFE;
  state->PC = 0x0100;

  constexpr Byte initial_io_registers[0x48] = {
  //0x00   0x01  0x02  0x03  0x04  0x05  0x06  0x07
    0xCF,  0x00, 0x7E, 0x00, 0x18, 0x00, 0x00, 0xF8, // $FF00 - $FF07
    0x00,  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE1, // $FF08 - $FF0F
    0x80,  0xBF, 0xF3, 0xFF, 0xBF, 0x00, 0x3F, 0x00, // $FF10 - $FF17
    0xFF,  0xBF, 0x7F, 0xFF, 0x9F, 0xFF, 0xBF, 0x00, // $FF18 - $FF1F
    0xFF,  0x00, 0x00, 0xBF, 0x77, 0xF3, 0xF1, 0x00, // $FF20 - $FF27
    0x00,  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, // $FF28 - $FF2F
    0x00,  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, // $FF30 - $FF37
    0x00,  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, // $FF38 - $FF3F
    0x91,  0x81, 0x00, 0x00, 0x91, 0x00, 0xFF, 0xFC  // $FF40 - $FF47
  };

  for (Short i = 0; i < 0x48; i++) {
    state->memory[0xFF00 + i] = initial_io_registers[i];
  }
}